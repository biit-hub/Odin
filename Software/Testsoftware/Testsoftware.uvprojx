# Keil uVision project Testsoftware.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Testsoftware
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F303RETx/STCubeGenerated/Src/: main.c stm32f3xx_it.c
    ./RTE/Device/STM32F303RETx/STCubeGenerated/Inc/: stm32f3xx_it.h
software components: CMSIS:CORE 5.6.0, Device:STM32Cube HAL 1.11.3
